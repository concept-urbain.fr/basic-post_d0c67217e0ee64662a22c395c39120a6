Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic potelet 2 à sceller.IFC
Time: 2020-07-01T12:34:57
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: BASI-POT-2-001-01_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 6.32745; Area Measure: 0.559824; Volume Measure: 0.000854183

# IfcBuildingElementProxy: BASI-POT-2-002_Default
In: Default Storey
Material: 6060
