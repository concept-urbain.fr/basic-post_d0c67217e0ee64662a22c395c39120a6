Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic potelet 1 à sceller.IFC
Time: 2020-07-01T12:34:03
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: BASI-POT-1-001-01_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 7.21769; Area Measure: 0.627645; Volume Measure: 0.00108507

# IfcBuildingElementProxy: BASI-POT-1-002_Default
In: Default Storey
Material: 6060

# IfcCurtainWall: RIV-INOX-6.4x18_Default
In: Default Storey
Material: AISI 304
