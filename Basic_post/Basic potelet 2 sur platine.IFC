Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic potelet 2 sur platine.IFC
Time: 2020-07-01T12:35:42
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: VEST-MUL-024_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: BASI-POT-2-004_Default
In: Default Storey
Material: AISI 304L

# IfcBuildingElementProxy: BASI-POT-2-PLAT-001-01_Default
In: Default Storey
Material: AISI 304
PSet_Mass_Property - Mass Measure: 9.15628; Area Measure: 0.639765; Volume Measure: 0.00114454
