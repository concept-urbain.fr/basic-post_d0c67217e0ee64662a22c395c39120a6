Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic potelet 1 amovible.IFC
Time: 2020-07-01T12:34:30
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-FOU-011_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: BASI-POT-1-AMO-002-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 11.6126; Area Measure: 0.878718; Volume Measure: 0.0016517

# IfcBuildingElementProxy: RIV-INOX-6.4x18_Default
In: Default Storey
Material: AISI 304
