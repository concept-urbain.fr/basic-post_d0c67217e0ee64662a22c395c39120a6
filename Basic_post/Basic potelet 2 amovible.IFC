Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic potelet 2 amovible.IFC
Time: 2020-07-01T12:35:21
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-FOU-011_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: BASI-POT-2-AMO-002-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 11.0001; Area Measure: 0.817147; Volume Measure: 0.00143182
